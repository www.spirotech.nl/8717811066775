Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2025-07-24T15:10:20+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: HC_Storage Tank_MEPcontent_Spirotech_SpiroStore_Buffer vessel_INT-EN:VB0030N08, HC_Storage Tank_MEPcontent_Spirotech_SpiroStore_Buffer vessel_INT-EN:VB0030N08:108868
In: Level 1
Type - Material: Color RGB 055-055-055, Color RAL 1003 (2), Color RGB 255-255-255 (2), Color RGB 255-000-000, Color RAL 7040
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Diameter: 305 mm; Drain: 19 mm; Height: 765 mm; Main Connection Diameter: 22 mm; Secondary Connection Diameter: 22 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: SpiroStore Buffer vessel steel; Article Type: VB0030N08; Base Family Version: 25.08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: SpiroStore Buffer vessel steel; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 25.08; GLN: 8717811000007; GTIN: 8717811066775; Manufacturer: Spirotech; Manufacturer Art. No.: VB0030N08; Manufacturer URL: https://www.spirotech.nl/producten/spirostore/spirostore-buffervat-288; MEPcontent Class: EXPANSIONVESSEL; Model: VB0030N08; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: SpiroExpand; Revit Version: 2023; Type Name: VB0030N08; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Grey: Color RAL 7040; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Mechanical - Volume: 0.03 m3
Type - Other - Category: Mechanical Equipment; B: 537 mm; D: 305 mm; Dirt Separator: M_Separator_Dirt__Geometry : UE022WH; Family Name: HC_Storage Tank_MEPcontent_Spirotech_SpiroStore_Buffer vessel_INT-EN; h: 283 mm; H1: 354 mm; H2: 424 mm; H3: 493 mm; L: 391 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Material: Color RGB 055-055-055, Color RAL 1003, Color RGB 255-255-255, Color RGB 255-000-000, Color RAL 7040
Pset_BuildingElementProxyCommon - Reference: VB0030N08
Pset_EnvironmentalImpactIndicators - Reference: VB0030N08
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 5.07939 m2; Volume: 0.0394931 m3
Identity Data - Mark: 1
Mechanical - System Classification: Undefined,Sanitary,Undefined
Mechanical - Flow - Drain Fixture Units: 0; Main Connection Flow 1: 0 m3/s; Main Connection Flow 2: 0 m3/s; Main Connection Flow 3: 0 m3/s; Main Connection Flow 4: 0 m3/s; Secondary Connection Flow 1: 0 m3/s; Secondary Connection Flow 2: 0 m3/s; Secondary Connection Flow 3: 0 m3/s; Secondary Connection Flow 4: 0 m3/s
Other - Family: HC_Storage Tank_MEPcontent_Spirotech_SpiroStore_Buffer vessel_INT-EN; Family and Type: HC_Storage Tank_MEPcontent_Spirotech_SpiroStore_Buffer vessel_INT-EN: VB0030N08; Front Clearance Safe: 500 mm; Left Clearance Safe: 500 mm; Right Clearance Safe: 500 mm; Top Clearance Safe: 500 mm; Type: VB0030N08; Type Id: 108851
Phasing - Phase Created: New Construction
Visibility - Front Clearance: 500 mm; Left Clearance: 500 mm; Right Clearance: 500 mm; Show Service Space: no; Top Clearance: 500 mm

# IfcDistributionPort (9)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
4 x Port_108868 | SINK
4 x Port_108868 | SOURCE
Port_108868 | SOURCE | SystemType: SEWAGE
